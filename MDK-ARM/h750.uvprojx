# Keil uVision project h750.uvprojx, settings and files
target h750 (6150000::V6.15::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h750 +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=6 v6LangP=7 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;                                 ../Drivers/STM32H7xx_HAL_Driver/Inc;                                 ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                                 ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                                 ../Drivers/CMSIS/Include;                                 ..\Hardware;                                 ..\ROS_Layer\Inc;                                 ..\Tuning_Utils;                                 ..\Control;                                 ..\ROS_Layer\Src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT8: RAM 0x30020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\h750\h750_cus.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_tim.c stm32h7xx_ll_gpio.c stm32h7xx_ll_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Hardware
    ../Hardware/: SCServo.c SCSProtocol.c Screen_drv.cpp StepperMotor.cpp
  group Control
    ../Control/: Control.c Servo.cpp
  group Tuning
    ../Tuning_Utils/: com.c DataScope_DP.C
  group ROS_Layer
    ../ROS_Layer/Src/: ros_support_layer.cpp
    ../ROS_Layer/Inc/: duration.cpp time.cpp
software components: CMSIS:CORE 5.2.0
